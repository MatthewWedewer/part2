# Keil uVision project take4.uvproj, settings and files
target Target 1 (MCS-51)
  device: 89C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: take4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: hardware_delay.c lcd.c main.c memory_test.c print_bytes.c uart.c spi.c SDcard.c
