# Keil uVision project part1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: part1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c memory_test.c print_bytes.c uart.c hardware_delay.c lcd.c SDcard.c spi.c Long_Serial_In.c
