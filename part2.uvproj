# Keil uVision project part2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: part2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: hardware_delay.c lcd.c Long_Serial_In.c main.c print_bytes.c SDcard.c spi.c uart.c Directory_Functions.c i2c.c
